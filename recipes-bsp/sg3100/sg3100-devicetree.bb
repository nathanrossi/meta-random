inherit devicetree

COMPATIBLE_MACHINE = "sg3100"
SRC_URI = "file://armada-380-sg3100.dts"

