inherit devicetree

COMPATIBLE_MACHINE = "raspberrypi3-b-plus"
SRC_URI = "file://bcm2837-rpi-3-b-plus-toolbox.dts"

