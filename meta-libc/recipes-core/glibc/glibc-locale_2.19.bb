require recipes-core/glibc/glibc-locale.inc

LOCALE_GENERATION_WITH_CROSS-LOCALEDEF_force = "0"
