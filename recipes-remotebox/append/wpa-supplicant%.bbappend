
BBCLASSEXTEND += "native nativesdk"
RRECOMMENDS_${PN}_class-native = ""

